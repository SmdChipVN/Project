# IAR project firework.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\2_Project\14_FireWork\code\c6t6\v2.0\include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\IC\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\0_Common\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\1_Application\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\2_SoftPeripheral\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\3_Middleware\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\4_Math\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\5_Algorithm\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\STM32F10x; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\STM32F10x\drive\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Module\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Protocol\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Sensor\0_include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: firework.out
  ILINK.IlinkIcfFile: firework.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    C:/Users/jfavl/OneDrive/Libraries/C&C++/: regulation.c
  group IC
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/IC/flashIC/: flashIC_0.c
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/IC/mfrc522/: mfrc522.c
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Module/mfrc522/: mfrc522_0.c
  group Microcontroller/Application
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Microcontroler/1_Application/button/: button_1.c
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Microcontroler/1_Application/led/: led_1.c
  group Microcontroller/Common
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Microcontroler/0_Common/: common.c
  group Microcontroller/Driver
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Microcontroler/STM32F10x/drive/: base_timer.c cortex_m3.c dma.c gpio.c rcc.c spi.c usb.c
  group Microcontroller/Driver/Startup
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Microcontroler/STM32F10x/startup/: startup_stm32f103cx.s system_stm32f1xx.c
  group Microcontroller/SoftPeripheral
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Microcontroler/2_SoftPeripheral/spi/: soft_spi_0.c
  group Microcontroller/System
    source/: firework.c firework_data.c main.c sound.c system.c
  group Microcontroller/System/Main test
    source/main_test/: main_led_button.c main_mass.c main_sound.c
  group Protocol/USB
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Protocol/USB/MASS/: USB_DATA.c USB_MASS.c
    C:/Users/jfavl/OneDrive/Libraries/C&C++/embedded_C99/Protocol/USB/: USBP.c
